# Keil uVision project TMPLATE.uvprojx, settings and files
target TMPLATE (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TMPLATE +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User/app;../User/bsp;../User/bsp/led;../User/bsp/beep;../User/bsp/debug;../User/bsp/PWM;../User/bsp/alarm;../User/bsp/co2;../User/bsp/dht;../User/bsp/light-R;../User/bsp/soil;../User/oled;../User/LoRa
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group User/app
    ../User/app/: app_main.c
  group User/bsp
    ../User/bsp/: ISR_callback.c
  group User/bsp/led
    ../User/bsp/led/: led.c
  group User/bsp/beep
    ../User/bsp/beep/: beep.c
  group User/bsp/debug
    ../User/bsp/debug/: debug.c
  group User/bsp/PWM
    ../User/bsp/PWM/: pwm.c
  group User/bsp/dht
    ../User/bsp/dht/: dht22.c
  group User/bsp/co2
    ../User/bsp/co2/: co2.c
  group User/bsp/alarm
    ../User/bsp/alarm/: alarm.c
  group User/bsp/light-R
    ../User/bsp/light-R/: light.c
  group User/bsp/soil
    ../User/bsp/soil/: soil.c
  group User/oled
    ../User/oled/: oled.c oled_demo.c oled_ui.c
  group User/LoRa
    ../User/LoRa/: llcc68.c llcc68_driver_version.c llcc68_hal.c llcc68_p2p.c lora_app.c
software components: CMSIS:CORE 4.3.0
